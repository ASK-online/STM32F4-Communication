# Keil uVision project I2C_Bare-Metal.uvprojx, settings and files
target Target_1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x8000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=2
  memory RVCT4: RAM 0x8000000 size 0x100000
  memory RVCT9: ROM 0x20000000 size 0x20000
  memory RVCT10: ROM 0x10000000 size 0x10000
  group Source Group 1
    ./: I2C_Simple.c
software components: CMSIS:CORE 5.2.0, Device:Startup 2.6.2
